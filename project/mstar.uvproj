# Keil uVision project mstar.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8xC51RD+ NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: mstar +hex
  c flags: Optimize=8
  c include: ..\inc;..\msLib;..\kernel;..\msFunc;
  asm include: ..\inc;..\msLib;..\kernel;..\msFunc;
  group Comm
    ../kernel/: Debug.c mcu.c isr.c main.c ms_rwreg.c misc.c global.c
    ./: L51_bank.a51
    ../mslib/: maria2_DSP.lib m9_VD_AGC.lib
  group Bank0
    ../msFunc/: userPref.c nvram.c keypad.c power.c adjust.c mode.c msVD.c devVD.c m2_VSYNC2.c
    ../kernel/: mstar.c
    ../mslib/: msACE.lib maria2_ACC.lib
    ../msLib/: maria2_FSC.lib
    D:/dev/lcd/mst/src/mstar/msLib/: m2_VD_Std.lib
  group Bank1
    ../msFunc/: MenuFunc.c menu.c MenuStr.c msOSD.c
